Commit message: Simplification du fichier URDF de la jambe/(bras)

File: Data/leg.urdf (robot description, URDF)
Before this commit: robot URDF, 8 links, 7 joints
Links:
- link left_foot_tip_link: mass 0 -> None
- link trunk_link: mass 0.001 -> None
