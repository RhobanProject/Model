Commit message: Good values for the pen. Duration average

File: Data/legWithPen.urdf (robot description, URDF)
Before this commit: robot URDF, 8 links, 7 joints
Joints:
- joint left_knee: origin xyz=0 0 -0.09375 rpy=0 0 0 -> xyz=0 0 -0.1249 rpy=0 0 0
